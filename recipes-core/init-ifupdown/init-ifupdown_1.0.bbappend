# Replace /etc/network/interfaces for opal6

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
