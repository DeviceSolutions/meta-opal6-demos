# Copyright (C) 2014 O.S. Systems Software LTDA.

require u-boot-opal6.bb
require recipes-bsp/u-boot/u-boot-mfgtool.inc
