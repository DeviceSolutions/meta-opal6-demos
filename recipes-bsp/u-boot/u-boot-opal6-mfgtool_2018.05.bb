# Copyright (C) 2014 O.S. Systems Software LTDA.

require u-boot-opal6_2018.05.bb
require recipes-bsp/u-boot/u-boot-mfgtool.inc
