PACKAGECONFIG_remove = "polkit"
PACKAGECONFIG_append = "mbim qmi"
